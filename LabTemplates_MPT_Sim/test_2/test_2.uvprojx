# Keil uVision project test_2.uvprojx, settings and files
target Simulation (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: test
  c flags: Optim=1
  c include: ..\Peripherals\Libraries
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source files
    ../Peripherals/Source Files/: GLCD_SPI_LPC1700.c gpio.c GLCD_Simulation.c lcd.c keys.c led.c
    ./: test_2.c
    ../Peripherals/Libraries/: lcd.h
target RAM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: as above
  output: test_2
  c flags: Optim=1
  c define: __TARGET_HW
  c include: ..\Peripherals\Libraries
  memory RVCT4: ROM 0x10000000 size 0x6000
  memory RVCT9: RAM 0x10006000 size 0x2000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
